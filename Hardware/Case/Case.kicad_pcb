File: Hardware/Case/Case.kicad_pcb (KiCad board)
At the start: 2 copper layers, 80.7 x 33.5 mm, 10 parts

Commit message: update case
Other:
- rule pad_to_mask_clearance: 0.05 -> 0
